# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM3
  c include: ..\..\..\ebox\hardware\cortex-m3;..\..\..\ebox\hardware\cortex-m3\Peripherals;..\..\..\ebox\core;..\..\..\ebox\core\mem;..\..\..\component;..\..\..\component\apps;..\..\..\mcuLib\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\CoreSupport;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\component\usb_device_stack\USBDevice;..\..\..\component\usb_device_stack\USBSerial;..\..\..\component\usb;..\..\..\user;..\..\..\component\ddc;..\..\..\ebox\core\math
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group start_code
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcuLib/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox_core
    ../../../ebox/core/: itoa.c big_little.cpp ebox_core.cpp list.cpp new.cpp print.cpp ringbuf.cpp util.cpp WString.cpp fifo.c ebox_printf.cpp
    ../../../ebox/core/mem/: ebox_mem.c
    ../../../ebox/core/math/: crc.c random.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m3/: mcu_core.cpp ebox_it.cpp object.cpp nvic.cpp dma.cpp
    ../../../ebox/hardware/cortex-m3/Peripherals/: ebox_analog.cpp ebox_dac.cpp ebox_encoder.cpp ebox_exti.cpp ebox_gpio.cpp ebox_i2c.cpp ebox_iflash.cpp ebox_in_capture.cpp ebox_pwm.cpp ebox_softi2c.cpp ebox_softspi.cpp ebox_spi.cpp ebox_timer.cpp ebox_uart.cpp ebox_wdg.cpp
  group user
    ../../../user/: main.cpp STM32_Init.c
  group usb
    ../../../component/usb/: cdcuser.c usart.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group ddc
    ../../../component/ddc/: ddc.c ddc_port.cpp listc.c ddc_user.cpp
